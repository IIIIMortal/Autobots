<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LQ_F3277_Lib.ewp</path>
    </project>
    <batchBuild />
</workspace>
